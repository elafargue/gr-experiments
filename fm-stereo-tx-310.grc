options:
  parameters:
    category: RDS
    generate_options: qt_gui
    id: rds_tx
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: fm_max_dev
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 89.5e6
  states: {}
- name: input_gain
  id: variable_qtgui_range
  parameters:
    label: Input Gain
    start: '0'
    step: '0.1e-6'
    stop: '50e-6'
    value: '10e-6'
  states: {}
- name: outbuffer
  id: variable
  parameters:
    value: '128'
  states: {}
- name: pilot_gain
  id: variable_qtgui_range
  parameters:
    label: Pilot Gain
    start: '0'
    step: '1e-3'
    stop: '500e-3'
    value: '90e-3'
  states: {}
- name: stereo_gain
  id: variable_qtgui_range
  parameters:
    label: Stereo Gain
    start: '0'
    step: '1e-3'
    stop: '300e-2'
    value: '300e-3'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 0.15e6
  states: {}
- name: usrp_sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      mkfifo stream.fifo
      while true; do mpg123 -r44100 -b 10  -s  http://maxxima.mine.nu:8000 >stream.fifo; done
    file: stream.fifo
    repeat: 'True'
    type: short
    vlen: '2'
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: pilot_gain
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: Multiply by input_gain
    const: input_gain
    type: float
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: input_gain
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_short_to_float_2
  id: blocks_short_to_float
  parameters:
    scale: '1'
    vlen: '2'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: usrp_sample_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: float
  states: {}
- name: gr_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: L + R audio
    type: float
  states: {}
- name: gr_add_xx_1
  id: blocks_add_xx
  parameters:
    maxoutbuf: outbuffer
    num_inputs: '3'
    type: float
  states: {}
- name: gr_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    maxoutbuf: outbuffer
    sensitivity: 2*math.pi*fm_max_dev/usrp_rate
  states: {}
- name: gr_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    comment: |-
      Translate the substracted
      L-R audio 38k above
    type: float
  states: {}
- name: gr_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: stereo_gain
    comment: 38k carrier for translation (see "Multiply" block)
    freq: 38e3
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: |-
      Add the stereo pilot tone
      (19 kHz)
    freq: 19e3
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: L - R audio
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '1'
    gain: '1'
    maxoutbuf: outbuffer
    samp_rate: usrp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '1'
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '1'
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: note_1
  id: note
  parameters:
    note: Test without radio
  states: {}
- name: note_2
  id: note
  parameters:
    note: Using USRP
  states: {}
- name: note_3
  id: note
  parameters:
    note: Using HackRF or other radios supported by Osmocom
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: 1e6
    freq0: freq
    gain0: '30'
    if_gain0: '30'
    sample_rate: usrp_sample_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: usrp_rate
    comment: |-
      This should display:
      - L+R Audio
      - 19k stereo pilot tone
      - L - R Audio above the 19k pilot tone
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(audio_rate/1e2)
    interp: int(usrp_rate/1e2)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Resample the input signal to the `usrp_rate` that
      is used for the rest of the flowgraph
    decim: int(audio_rate/1e2)
    interp: int(usrp_rate/1e2)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Resampling to go from the sample rate used in the graph
      to the rate expected by the Sink
    decim: int(usrp_rate/10000)
    interp: int(usrp_sample_rate/1e4)
    maxoutbuf: outbuffer
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: '30'
    len_tag_name: ''
    maxoutbuf: outbuffer
    samp_rate: usrp_sample_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_short_to_float_2, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', gr_add_xx_1, '2']
- [blocks_multiply_const_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_xx_1, '0', low_pass_filter_0_0_0, '0']
- [blocks_short_to_float_2, '0', blocks_vector_to_streams_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_streams_0, '0', rational_resampler_xxx_0, '0']
- [blocks_vector_to_streams_0, '1', rational_resampler_xxx_0_0, '0']
- [gr_add_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [gr_add_xx_1, '0', gr_frequency_modulator_fc_0, '0']
- [gr_add_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [gr_frequency_modulator_fc_0, '0', low_pass_filter_0, '0']
- [gr_multiply_xx_1, '0', gr_add_xx_1, '0']
- [gr_sig_source_x_0, '0', gr_multiply_xx_1, '1']
- [gr_sig_source_x_0_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [gr_sub_xx_0, '0', blocks_multiply_const_xx_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0_0, '0', gr_add_xx_1, '1']
- [low_pass_filter_0_0_0, '0', gr_multiply_xx_1, '0']
- [rational_resampler_xxx_0, '0', gr_add_xx_0, '0']
- [rational_resampler_xxx_0, '0', gr_sub_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', gr_add_xx_0, '1']
- [rational_resampler_xxx_0_0, '0', gr_sub_xx_0, '1']
- [rational_resampler_xxx_1, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_1, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_1, '0', uhd_usrp_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
