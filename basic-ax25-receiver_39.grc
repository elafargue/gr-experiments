options:
  parameters:
    author: Ed Lafargue <ed@wizkers.io>
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Simple Ax25 demodulation
  states: {}

blocks:
- name: EBW
  id: variable
  parameters:
    value: '.05'
  states: {}
- name: RRC_filter_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: EBW
    comment: Root raised cosine definition.
    gain: nfilts
    ntaps: int(samples_per_symbol*nfilts)
    samp_rate: nfilts
    sym_rate: baud_rate
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: |-
      Needs to be a multiple of baud rate: 48k or 24k
      work well for 1200 baud
    value: '48000'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: fm_deviation_hz
  id: variable
  parameters:
    comment: |-
      The FM deviation.
      5kHz or even 2.5kHz  is typical for narrow band FM, while broadcast FM
      would use 76kHz
    value: 2.5e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 144.390e6
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    comment: |-
      Don't modify by hand, automatically
      calculated based on High/Low fsk freq
    value: high_fsk_freq-low_fsk_freq
  states: {}
- name: high_fsk_freq
  id: variable
  parameters:
    value: '2200'
  states: {}
- name: low_fsk_freq
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: audio_rate/baud_rate
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    comment: |-
      AX25 transmitters will apply pre-emphasis at 1200 baud,
      but in practice, many people use DIY modems and sometime
      do not set things up properly. Enable and see
      if you receive more packets.
    samp_rate: samp_rate
    tau: '200e-6'
  states: {state: bypassed}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: Demodulate the FM signal
    gain: samp_rate/(2*math.pi*fm_deviation_hz/8.0)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      This time we are demodulating
      the FSK proper, not the audio signal.

      Note: gain does not have a major impact on
      decoding success (see what happens with a gain
      of 1)
    gain: audio_rate/(2*math.pi*fsk_deviation/8.0)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      At this stage we have recovered
      the baseband audio signal
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test1
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      Make sure you adjust the sample rate to the
      actual rate of the IQ file
    file: /Users/elafargue/Documents/Prodsec/Radio/gr-experiments/samples/aprs-144.39-250k-35dBGain.complex
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    comment: |-
      AX25 is NRZ (or "differential") encoded, and inverted,
      so we apply the relevant corrections here
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: pdu_length
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7788'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      Use this to demodulate
      audio files directly
    file: /Users/elafargue/Documents/Prodsec/Radio/gr-experiments/samples/aprs-1200.wav
    repeat: 'True'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: |-
      This clock recovery mechanism seems to perform
      much better, experiment by enabling one or the
      other
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samples_per_symbol*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    comment: |-
      AX25 is framed using HDLC, and Gnuradio comes
      with a HDLC deframer, we are lucky.

      This checks that the CRC is valid, so only frames
      whose CRC is correct will be forwarded on in the
      flowgraph.
    max: '500'
    min: '32'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    comment: |-
      Clock recovery: turns the raw signal with "0" and "1"
      amplitudes - many "0"s and "1" for each bit - , into the
      actual bitstream.

      Uses the knowledge we have of the signal to recover
      the clock (baud rate and sample rate)
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*math.pi/400.0*2/70
    max_dev: '2'
    osps: '1'
    sps: samples_per_symbol
    taps: RRC_filter_taps
    type: fff
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (low_fsk_freq+high_fsk_freq) / 2
    comment: |-
      Recenter the audio around 0Hz.
      Parameters adjusted using a reference
      recording to maximize decoding
    decim: '1'
    samp_rate: audio_rate
    taps: firdes.low_pass(1.0,audio_rate,fsk_deviation, 350)
    type: fcf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      The cutoff frequency can be aggressive
      to avoid useless power getting into the chain,
      this improves decoding quite a bit.
    cutoff_freq: 3*fm_deviation_hz
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: fm_deviation_hz
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: fsk_deviation
    gain: '1'
    interp: '1'
    samp_rate: audio_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      A simple AFSK demodulator

      This is a receiver that demodulates AFSK sent over
      a narrow FM signal, such as AX25/APRS used in amateur
      radio.

      The first part is a standard Narrow FM demodulator,
      then the resulting audio output is FSK-demodulated.
    note: Introduction
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,1,1
    label1: '""'
    name: '"Quadrature Demod Output"'
    size: int(audio_rate / 10)
    srate: audio_rate
    type: float
    ymax: '25'
    ymin: '-25'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: Raw bitstream
    marker1: '0'
    size: int(audio_rate/10)
    srate: audio_rate
    type: float
    ymin: '-0.01'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    label1: Recovered bitstream
    size: int(audio_rate/(10*samples_per_symbol))
    srate: audio_rate/samples_per_symbol
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ylabel: Bit state
    ymin: '-0.01'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: int(audio_rate/500*2)
    freqhalf: 'False'
    gui_hint: 0,0,1,1
    name: '"Audio Spectrum"'
    showports: 'True'
    type: complex
    update_time: 500./audio_rate
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/1000)
    interp: int(audio_rate/1000)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    interp: audio_rate/100
    taps: ''
    type: fff
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: '200000'
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_fm_deemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', low_pass_filter_1, '0']
- [blocks_and_const_xx_0, '0', blocks_char_to_float_1_0, '0']
- [blocks_and_const_xx_0, '0', digital_hdlc_deframer_bp_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_1_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_not_xx_0, '0', blocks_and_const_xx_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_udp_sink_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_1, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_not_xx_0, '0']
- [digital_hdlc_deframer_bp_0, out, blocks_message_debug_0, print_pdu]
- [digital_hdlc_deframer_bp_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_pfb_clock_sync_xxx_0, '0', digital_binary_slicer_fb_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_1, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_1, '0', digital_clock_recovery_mm_xx_0, '0']
- [low_pass_filter_1, '0', digital_pfb_clock_sync_xxx_0, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
